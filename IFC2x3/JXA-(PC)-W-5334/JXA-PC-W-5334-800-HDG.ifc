Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Projektnummer
Time: 2018-11-02T15:42:56
Author: DNe, DNE@jordahl.de
Organization: JORDAHL GmbH
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 02 15:42:56 2018 * Host: JORNBBLN-012 * Database: C:\Users\DENNIS~1.NEU\AppData\Local\Temp\{4F6F6E30-1595-47B6-8063-C46CC4FDE125}\ifc * Database version: 5507 * Database creation date: Fri Nov 02 15:42:54 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 02 15:42:55 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 02 15:42:55 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene -1
LongName: Ebene -1; Elevation: -3 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Abhängigkeiten - Ansicht: -3 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene -1; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene

# IfcFastener: JXA(-PC) L=800 mm, JXA(-PC) JORDAHL® toothed channels:JXA(-PC) L=800 mm:423582
In: Ebene -1
Type - Material: Steel
Type - Abhängigkeiten(Type) - length: 0.8 m; Vorgabe-Ansicht: 0 m
Type - Allgemein(Type) - min number anchor: 2; tk: 0.002 m
Type - Daten(Type) - min_number_of_T_bolts: 2
Type - ID-Daten(Type) - Beschreibung: Together with the JORDAHL® toothed T-bolts and JORDAHL® accessories, the hot-rolled toothed JORDAHL® anchor channels provide a secure, form-fitting connection along the longitudinal axis of the channel. They can absorb static and dynamic tensile loads, shear loads and longitudinal tension.; Hersteller: JORDAHL®; LOD: 300; Modell: JXA(-PC) W; Typname: JXA(-PC) L=800 mm; URL: http://www.jordahl-group.com/en/354/products/fastening-technology/toothed-channels-jxa/; Version: 2017-1
Type - Sichtbarkeit(Type) - proof 29-20: W 29-20 JXA JORDAHL®; proof 38-23: W 38-23 JXA JORDAHL®; proof 53-34: W 53-34 JXA JORDAHL®; proof 64-44: W 64-44 JXA JORDAHL®
Type - Sonstige(Type) - Kategorie: Anschluss; Familienname: JXA(-PC) JORDAHL® toothed channels
Type - Text(Type) - OmniClass Code: 23-13 23 11 11
Pset_ManufacturerTypeInformation - Manufacturer: JORDAHL®
Abhängigkeiten - Assessment Z-21.4-1690: http://downloads.jordahl-group.com/files/approvals/abZ-Z-21.4-1690-JXA-2018.pdf; Basisbauteil: Ebene : Ebene -1; channel profil: W 53-34 JXA JORDAHL®; Ebene: Ebene: Ebene -1; Erhebung: 0 m; JXA-PC: yes; larger T-Bolt size: no; Warning Overconstraint: no; Website: http://www.jordahl-group.com/en/354/products/fastening-technology/toothed-channels-jxa/
Abmessungen - Fläche: 0.150684 m2; Volumen: 0.000676416 m3
Allgemein - calculate H: 0.146 m; calculate max spacing anchor: 0.25 m; calculate ØbA: 0.007 m; calculate ØD: 0.021 m; calculate Øk1: 0.021 m; edge distance anchor: 0.035 m; number anchor: 4; ØbA: 0.014 m; ØD: 0.042 m; Øk1: 0.042 m; tD: 0.003 m
Daten - b1: 0.021 m; b2: 0.042 m; calculated_number_of_T_bolts: 2; edge distance of the first T Bolt: 0.399 m; k: 0.012 m; l: 0.06 m; max_spacing_length: 0.73 m; max clamping length: 0.04 m; min_spacing_length: 0.08 m; nut_1: no; nut_pair: no; Ød_SharedParameter: 0.016 m; T Bolt group spacing: 0.001 m; T Bolt min length: 0.03 m
ID-Daten - tender text: gezahnte JORDAHL® Ankerschiene JXA ... / ... oder gleichwertig zum Einbetonieren, Material:feuerverzinkt (fv) oder Edelstahl 1.4401; 1.4571; 1.4404 (A4) mit Vollschaumfüllung, nach allgemeiner bauaufsichtlicher Zulassung des DIBt (Zul.Nr. Z-21.4-1690), versehen mit dem RAL Gütezeichen RAL-GZ 658/1 der Gütegemeinschaft Verankerungs- und Bewehrungstechnik e.V. Einzellänge ........ mm, Belastung Fy/Fz und Fx in Schienenrichtung bis ........kN/Befestigungspunkt, bis ......kN nicht ruhende Beanspruchung zulässig, für die justierbare Befestigung von Anschluss- konstruktionen, liefern und entsprechend der Einbau- anleitung des Herstellers an der Schalung befestigen.
Konstruktion - min T Bolt edge distance: 0.035 m; number of T Bolts: 0; T Bolt diameter: 0.016 m; T Bolt length: 0.06 m; T Bolt spacing: 0.1 m; T Bolt type: JXB M16; thickness of attaching part: 0.01 m
Materialien und Oberflächen - material hot-dip Galvanised steel: yes; material stainless steel: no
Modelleigenschaften - b: 0.053 m; d: 0.0225 m; f: 0.008 m; f1: 0.006 m; h: 0.034 m; t1: 0.004 m
Phasen - Phase erstellt: Phase 1
Sonstige - Bauteillistenebene: Ebene: Ebene -1; D_washer: 0.03 m; Familie: JXA(-PC) JORDAHL® toothed channels: JXA(-PC) L=800 mm; Familie und Typ: JXA(-PC) JORDAHL® toothed channels: JXA(-PC) L=800 mm; Kategorie: Anschluss; m_nut: 0.0148 m; r_Ød: 0.008 m; s_nut: 0.024 m; s_washer: 0.003 m; Typ: JXA(-PC) JORDAHL® toothed channels: JXA(-PC) L=800 mm; Typ-ID: JXA(-PC) JORDAHL® toothed channels: JXA(-PC) L=800 mm
Text - Pos.: 1a
Tragwerk - Bewehrungsüberdeckung: Bewehrungsüberdeckung - Einstellungen: Bewehrungsabdeckung 1
